options:
  parameters:
    author: alecp
    generate_options: qt_gui
    id: fm_broadcast
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_entry
  parameters:
    label: Audio Gain
    type: real
    value: '.01'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 100e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: fm_station
  id: variable_qtgui_chooser
  parameters:
    label: FM Station
    label0: Country
    label1: Pop
    label2: Hip-Hop
    label3: Not Sure
    num_opts: '4'
    option0: 99.1e6
    option1: 99.9e6
    option2: 102.9e6
    option3: 101.1e6
    orient: Qt.QHBoxLayout
    type: real
    value: 99.1e6
    widget: radio_buttons
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: RF Frequency
    type: real
    value: 98.8e6
  states: {}
- name: recording_duration
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rf_gain
  id: variable_qtgui_entry
  parameters:
    label: RF Gain
    type: real
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3.2e6
  states: {}
- name: tune_freq
  id: variable_qtgui_entry
  parameters:
    label: Tune Frequency (Hz)
    type: real
    value: 300e3
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      Obtains Instantaneous Freq
      of a Signal
    gain: '1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: tune_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\alecp\OneDrive\Documents\GNU-Radio\Tutorial\fm_recording.c64
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\alecp\OneDrive\Documents\GNU-Radio\Tutorial\fm_recording.c64
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: |-
      Multiply number of seconds by sample rate
      Use round, if needed
    num_items: round(samp_rate*recording_duration)
    type: complex
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: Negative Multiplication
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: Use this to play recording in real time
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: |-
      Decimation of 10: 
      Compute 1 sample, throw out 9
    cutoff_freq: 100e3
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 25e3
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_1
  id: filter_fft_low_pass_filter
  parameters:
    comment: Attenuates tone at 19KHz
    cutoff_freq: 18e3
    decim: '1'
    gain: '1'
    samp_rate: 48e3
    type: fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    nconnections: '2'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    name: Low Pass Filter Spectrum
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate / decimation
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      Use this to Interpolate by 48 
      and Decimate by 320 to sample down 
      to 48KHz
      3 / 20 the same as 48 / 320
      Can put in our own filter taps
    decim: '20'
    interp: '3'
    type: fff
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: LNAW
    center_freq0: fm_station - (tune_freq)
    comment: |-
      If using LimeSDR Mini: LNAW
      If using LimeSDR USB: LNAL
    driver: lime
    gain0: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [filter_fft_low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [filter_fft_low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [filter_fft_low_pass_filter_1, '0', blocks_multiply_const_vxx_0, '0']
- [filter_fft_low_pass_filter_1, '0', qtgui_freq_sink_x_2, '0']
- [rational_resampler_xxx_0, '0', filter_fft_low_pass_filter_1, '0']
- [soapy_custom_source_0, '0', blocks_head_0, '0']
- [soapy_custom_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [soapy_custom_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
