options:
  parameters:
    generate_options: qt_gui
    id: limesdr_2
    output_language: python
    title: LimeSDR Demo
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_entry
  parameters:
    label: Frequency (Hz)
    type: real
    value: 25e6
  states: {}
- name: rf_gain
  id: variable_qtgui_entry
  parameters:
    label: RF gain
    type: real
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3.2e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: frequency
    fftsize: '4096'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '4096'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    center_freq: frequency
    gain: rf_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_limesdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
